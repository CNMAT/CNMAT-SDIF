#ifndef SDIF_BOOLEAN
typedef unsigned char Boolean;
#undef TRUE
#define TRUE 1
#undef FALSE
#define FALSE 0
#define SDIF_BOOLEAN
#endif


#include <stdio.h>
#include <stdarg.h>

#include "sdif.h"
#include "sdif-mem.h"
#include "sdif-buf.h"
#include "sdif-interp.h"
#include "sdif-util.h"
#include "sdif-unit.h"
#include "sdif-unit-utils.h"


void unit_PrintBuffer(SDIFunitLogLevel level, SDIFbuf_Buffer buf)
{
  SDIFmem_Frame f;
  
  for(f = SDIFbuf_GetFirstFrame(buf); f; f = SDIFbuf_GetNextFrame(f))
    unit_PrintFrame(level, f);
}


void unit_PrintFrame(SDIFunitLogLevel level, SDIFmem_Frame f)
{
  SDIFmem_Matrix m;
  
  unit_log(level, "**frame\n");
  unit_log(level, "header.time=%f\n", f->header.time);
  unit_log(level, "header.frameType=");
  unit_PrintChar4(level, f->header.frameType);
  unit_log(level, "\n");
  
  for(m = f->matrices; m; m = m->next)
    unit_PrintMatrix(level, m);
}


void unit_PrintMatrix(SDIFunitLogLevel level, SDIFmem_Matrix m)
{
  int columns, rows;
  int i, j;
  
  unit_log(level, "*matrix\n");
  unit_log(level, "header.matrixType=");
  unit_PrintChar4(level, m->header.matrixType);
  unit_log(level, "\n");
  unit_log(level, "header.matrixDataType=%4.4x\n", m->header.matrixDataType);
  unit_log(level, "header.numColumns=%d\n", m->header.columnCount);
  unit_log(level, "header.numRows=%d\n", m->header.rowCount);
  for(i = 0; i < m->header.rowCount; i++)
  {
    for(j = 0; j < m->header.columnCount; j++)
      unit_log(level, "%f ", SDIFutil_GetMatrixCell(m, j, i));
    unit_log(level, "\n");
  }
}


void unit_PrintChar4(SDIFunitLogLevel level, const char *t)
{
  unit_log(level, "\'%c%c%c%c\'", t[0], t[1], t[2], t[3]);
}
